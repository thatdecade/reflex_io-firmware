#include "config_mode.h"
#include <string.h>

// Precomputed magic signatures for entering and exiting config mode.
// These values match the SHA-512 for "REFLEXENTERCONFIG" and "REFLEXEXITCONFIG"
static const uint8_t enter_config_magic[64] = {
    0xb6, 0xda, 0x3d, 0xc8, 0x90, 0x4a, 0xae, 0x15,
    0x87, 0xf7, 0xee, 0x99, 0x13, 0xc8, 0xbc, 0x5f,
    0x4e, 0x61, 0x6d, 0x7b, 0x75, 0x05, 0xc4, 0xb3,
    0x62, 0x20, 0xc9, 0xa7, 0x84, 0x18, 0x66, 0xd1,
    0x87, 0x27, 0x82, 0xb8, 0x7c, 0xaa, 0xe1, 0xbf,
    0x41, 0xc0, 0x01, 0xc4, 0x57, 0xd4, 0xe1, 0xe3,
    0xd5, 0x4b, 0x5d, 0xb6, 0xa6, 0xc1, 0x67, 0x68,
    0xa6, 0x15, 0x73, 0x5f, 0x43, 0xc9, 0x5a, 0xb3
};

static const uint8_t exit_config_magic[64] = {
    0x7f, 0x54, 0x55, 0xb2, 0x0d, 0x20, 0x11, 0x05,
    0xe6, 0x4b, 0x98, 0x52, 0xcf, 0x49, 0x11, 0x47,
    0x5c, 0xef, 0xae, 0x3d, 0x39, 0xbd, 0xe6, 0xba,
    0xa1, 0x2d, 0x69, 0xb1, 0x4d, 0xf3, 0xc6, 0x1d,
    0x71, 0xff, 0xbc, 0x33, 0x09, 0x1f, 0xd4, 0x10,
    0x34, 0xe5, 0x45, 0xb0, 0xfa, 0xe1, 0x89, 0xda,
    0xfc, 0x3a, 0x32, 0xdf, 0xe9, 0x7a, 0x8d, 0xd6,
    0xb7, 0x23, 0x8b, 0x33, 0xbd, 0xd6, 0x5e, 0xa6
};

static ConfigMode current_mode = CONFIG_MODE_NORMAL;

bool is_config_mode(void) {
    return (current_mode == CONFIG_MODE_ENTER);
}

void set_config_mode(ConfigMode mode) {
    if (mode == CONFIG_MODE_ENTER) {
        current_mode = CONFIG_MODE_ENTER;
    } else if (mode == CONFIG_MODE_EXIT) {
        current_mode = CONFIG_MODE_NORMAL;
    } else {
        current_mode = CONFIG_MODE_NORMAL;
    }
}

ConfigMode packet_filter_for_config_mode(const uint8_t *packet) {
    if (memcmp(packet, enter_config_magic, 64) == 0) {
        return CONFIG_MODE_ENTER;
    }
    if (memcmp(packet, exit_config_magic, 64) == 0) {
        return CONFIG_MODE_EXIT;
    }
    return CONFIG_MODE_NORMAL;
}
